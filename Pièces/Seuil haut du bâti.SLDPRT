ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(0.,0.,-10.));
#20=DIRECTION('',(-1.,0.,0.));
#21=DIRECTION('',(0.,0.,1.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=PLANE('',#22);
#24=DIRECTION('',(0.,-1.,0.));
#25=VECTOR('',#24,1.);
#26=CARTESIAN_POINT('',(0.,0.,0.));
#27=LINE('',#26,#25);
#28=CARTESIAN_POINT('',(0.,200.,0.));
#29=VERTEX_POINT('',#28);
#30=CARTESIAN_POINT('',(0.,0.,0.));
#31=VERTEX_POINT('',#30);
#32=EDGE_CURVE('E366',#29,#31,#27,.T.);
#33=ORIENTED_EDGE('',*,*,#32,.F.);
#34=DIRECTION('',(0.,0.,1.));
#35=VECTOR('',#34,1.);
#36=CARTESIAN_POINT('',(0.,200.,-10.));
#37=LINE('',#36,#35);
#38=CARTESIAN_POINT('',(0.,200.,-10.));
#39=VERTEX_POINT('',#38);
#40=EDGE_CURVE('E11',#39,#29,#37,.T.);
#41=ORIENTED_EDGE('',*,*,#40,.F.);
#42=DIRECTION('',(0.,-1.,0.));
#43=VECTOR('',#42,1.);
#44=CARTESIAN_POINT('',(0.,0.,-10.));
#45=LINE('',#44,#43);
#46=CARTESIAN_POINT('',(0.,0.,-10.));
#47=VERTEX_POINT('',#46);
#48=EDGE_CURVE('E420',#39,#47,#45,.T.);
#49=ORIENTED_EDGE('',*,*,#48,.T.);
#50=DIRECTION('',(0.,0.,1.));
#51=VECTOR('',#50,1.);
#52=CARTESIAN_POINT('',(0.,0.,-10.));
#53=LINE('',#52,#51);
#54=EDGE_CURVE('E29',#47,#31,#53,.T.);
#55=ORIENTED_EDGE('',*,*,#54,.T.);
#56=EDGE_LOOP('',(#33,#41,#49,#55));
#57=FACE_BOUND('',#56,.T.);
#58=ADVANCED_FACE('F26',(#57),#23,.T.);
#59=CARTESIAN_POINT('',(0.,200.,-10.));
#60=DIRECTION('',(0.,1.,0.));
#61=DIRECTION('',(0.,0.,1.));
#62=AXIS2_PLACEMENT_3D('',#59,#60,#61);
#63=PLANE('',#62);
#64=DIRECTION('',(-1.,0.,0.));
#65=VECTOR('',#64,1.);
#66=CARTESIAN_POINT('',(0.,200.,0.));
#67=LINE('',#66,#65);
#68=CARTESIAN_POINT('',(300.,200.,0.));
#69=VERTEX_POINT('',#68);
#70=EDGE_CURVE('E417',#69,#29,#67,.T.);
#71=ORIENTED_EDGE('',*,*,#70,.F.);
#72=DIRECTION('',(0.,0.,1.));
#73=VECTOR('',#72,1.);
#74=CARTESIAN_POINT('',(300.,200.,-10.));
#75=LINE('',#74,#73);
#76=CARTESIAN_POINT('',(300.,200.,-10.));
#77=VERTEX_POINT('',#76);
#78=EDGE_CURVE('E34',#77,#69,#75,.T.);
#79=ORIENTED_EDGE('',*,*,#78,.F.);
#80=DIRECTION('',(-1.,0.,0.));
#81=VECTOR('',#80,1.);
#82=CARTESIAN_POINT('',(0.,200.,-10.));
#83=LINE('',#82,#81);
#84=EDGE_CURVE('E429',#77,#39,#83,.T.);
#85=ORIENTED_EDGE('',*,*,#84,.T.);
#86=ORIENTED_EDGE('',*,*,#40,.T.);
#87=EDGE_LOOP('',(#71,#79,#85,#86));
#88=FACE_BOUND('',#87,.T.);
#89=ADVANCED_FACE('F443',(#88),#63,.T.);
#90=CARTESIAN_POINT('',(300.,0.,-10.));
#91=DIRECTION('',(1.,0.,0.));
#92=DIRECTION('',(0.,0.,-1.));
#93=AXIS2_PLACEMENT_3D('',#90,#91,#92);
#94=PLANE('',#93);
#95=DIRECTION('',(0.,1.,0.));
#96=VECTOR('',#95,1.);
#97=CARTESIAN_POINT('',(300.,0.,0.));
#98=LINE('',#97,#96);
#99=CARTESIAN_POINT('',(300.,0.,0.));
#100=VERTEX_POINT('',#99);
#101=EDGE_CURVE('E414',#100,#69,#98,.T.);
#102=ORIENTED_EDGE('',*,*,#101,.F.);
#103=DIRECTION('',(0.,0.,1.));
#104=VECTOR('',#103,1.);
#105=CARTESIAN_POINT('',(300.,0.,-10.));
#106=LINE('',#105,#104);
#107=CARTESIAN_POINT('',(300.,0.,-10.));
#108=VERTEX_POINT('',#107);
#109=EDGE_CURVE('E432',#108,#100,#106,.T.);
#110=ORIENTED_EDGE('',*,*,#109,.F.);
#111=DIRECTION('',(0.,1.,0.));
#112=VECTOR('',#111,1.);
#113=CARTESIAN_POINT('',(300.,0.,-10.));
#114=LINE('',#113,#112);
#115=EDGE_CURVE('E426',#108,#77,#114,.T.);
#116=ORIENTED_EDGE('',*,*,#115,.T.);
#117=ORIENTED_EDGE('',*,*,#78,.T.);
#118=EDGE_LOOP('',(#102,#110,#116,#117));
#119=FACE_BOUND('',#118,.T.);
#120=ADVANCED_FACE('F449',(#119),#94,.T.);
#121=CARTESIAN_POINT('',(0.,0.,-10.));
#122=DIRECTION('',(0.,-1.,0.));
#123=DIRECTION('',(0.,0.,-1.));
#124=AXIS2_PLACEMENT_3D('',#121,#122,#123);
#125=PLANE('',#124);
#126=DIRECTION('',(1.,0.,0.));
#127=VECTOR('',#126,1.);
#128=CARTESIAN_POINT('',(0.,0.,0.));
#129=LINE('',#128,#127);
#130=EDGE_CURVE('E411',#31,#100,#129,.T.);
#131=ORIENTED_EDGE('',*,*,#130,.F.);
#132=ORIENTED_EDGE('',*,*,#54,.F.);
#133=DIRECTION('',(1.,0.,0.));
#134=VECTOR('',#133,1.);
#135=CARTESIAN_POINT('',(0.,0.,-10.));
#136=LINE('',#135,#134);
#137=EDGE_CURVE('E423',#47,#108,#136,.T.);
#138=ORIENTED_EDGE('',*,*,#137,.T.);
#139=ORIENTED_EDGE('',*,*,#109,.T.);
#140=EDGE_LOOP('',(#131,#132,#138,#139));
#141=FACE_BOUND('',#140,.T.);
#142=ADVANCED_FACE('F440',(#141),#125,.T.);
#143=CARTESIAN_POINT('',(0.,200.,-10.));
#144=DIRECTION('',(0.,0.,-1.));
#145=DIRECTION('',(-1.,0.,0.));
#146=AXIS2_PLACEMENT_3D('',#143,#144,#145);
#147=PLANE('',#146);
#148=CARTESIAN_POINT('',(250.,11.,-10.));
#149=DIRECTION('',(0.,0.,-1.));
#150=DIRECTION('',(-1.,0.,0.));
#151=AXIS2_PLACEMENT_3D('',#148,#149,#150);
#152=CIRCLE('',#151,6.00000000000002);
#153=CARTESIAN_POINT('',(244.,11.,-10.));
#154=VERTEX_POINT('',#153);
#155=EDGE_CURVE('E783',#154,#154,#152,.T.);
#156=ORIENTED_EDGE('',*,*,#155,.F.);
#157=EDGE_LOOP('',(#156));
#158=FACE_BOUND('',#157,.T.);
#159=CARTESIAN_POINT('',(20.,20.,-10.));
#160=DIRECTION('',(0.,0.,-1.));
#161=DIRECTION('',(-1.,0.,0.));
#162=AXIS2_PLACEMENT_3D('',#159,#160,#161);
#163=CIRCLE('',#162,4.99999999999999);
#164=CARTESIAN_POINT('',(15.,20.,-10.));
#165=VERTEX_POINT('',#164);
#166=EDGE_CURVE('E805',#165,#165,#163,.T.);
#167=ORIENTED_EDGE('',*,*,#166,.F.);
#168=EDGE_LOOP('',(#167));
#169=FACE_BOUND('',#168,.T.);
#170=CARTESIAN_POINT('',(20.,180.,-10.));
#171=DIRECTION('',(0.,0.,-1.));
#172=DIRECTION('',(-1.,0.,0.));
#173=AXIS2_PLACEMENT_3D('',#170,#171,#172);
#174=CIRCLE('',#173,4.99999999999999);
#175=CARTESIAN_POINT('',(15.,180.,-10.));
#176=VERTEX_POINT('',#175);
#177=EDGE_CURVE('E811',#176,#176,#174,.T.);
#178=ORIENTED_EDGE('',*,*,#177,.F.);
#179=EDGE_LOOP('',(#178));
#180=FACE_BOUND('',#179,.T.);
#181=CARTESIAN_POINT('',(280.,20.,-10.));
#182=DIRECTION('',(0.,0.,-1.));
#183=DIRECTION('',(-1.,0.,0.));
#184=AXIS2_PLACEMENT_3D('',#181,#182,#183);
#185=CIRCLE('',#184,4.99999999999999);
#186=CARTESIAN_POINT('',(275.,20.,-10.));
#187=VERTEX_POINT('',#186);
#188=EDGE_CURVE('E817',#187,#187,#185,.T.);
#189=ORIENTED_EDGE('',*,*,#188,.F.);
#190=EDGE_LOOP('',(#189));
#191=FACE_BOUND('',#190,.T.);
#192=CARTESIAN_POINT('',(280.,180.,-10.));
#193=DIRECTION('',(0.,0.,-1.));
#194=DIRECTION('',(-1.,0.,0.));
#195=AXIS2_PLACEMENT_3D('',#192,#193,#194);
#196=CIRCLE('',#195,4.99999999999999);
#197=CARTESIAN_POINT('',(275.,180.,-10.));
#198=VERTEX_POINT('',#197);
#199=EDGE_CURVE('E829',#198,#198,#196,.T.);
#200=ORIENTED_EDGE('',*,*,#199,.F.);
#201=EDGE_LOOP('',(#200));
#202=FACE_BOUND('',#201,.T.);
#203=DIRECTION('',(0.,1.,0.));
#204=VECTOR('',#203,1.);
#205=CARTESIAN_POINT('',(200.,30.,-10.));
#206=LINE('',#205,#204);
#207=CARTESIAN_POINT('',(200.,30.,-10.));
#208=VERTEX_POINT('',#207);
#209=CARTESIAN_POINT('',(200.,70.,-10.));
#210=VERTEX_POINT('',#209);
#211=EDGE_CURVE('E295',#208,#210,#206,.T.);
#212=ORIENTED_EDGE('',*,*,#211,.T.);
#213=DIRECTION('',(1.,0.,0.));
#214=VECTOR('',#213,1.);
#215=CARTESIAN_POINT('',(200.,70.,-10.));
#216=LINE('',#215,#214);
#217=CARTESIAN_POINT('',(210.,70.,-10.));
#218=VERTEX_POINT('',#217);
#219=EDGE_CURVE('E298',#210,#218,#216,.T.);
#220=ORIENTED_EDGE('',*,*,#219,.T.);
#221=DIRECTION('',(0.,1.,0.));
#222=VECTOR('',#221,1.);
#223=CARTESIAN_POINT('',(210.,70.,-10.));
#224=LINE('',#223,#222);
#225=CARTESIAN_POINT('',(210.,90.,-10.));
#226=VERTEX_POINT('',#225);
#227=EDGE_CURVE('E42',#218,#226,#224,.T.);
#228=ORIENTED_EDGE('',*,*,#227,.T.);
#229=DIRECTION('',(-1.,0.,0.));
#230=VECTOR('',#229,1.);
#231=CARTESIAN_POINT('',(210.,90.,-10.));
#232=LINE('',#231,#230);
#233=CARTESIAN_POINT('',(200.,90.,-10.));
#234=VERTEX_POINT('',#233);
#235=EDGE_CURVE('E301',#226,#234,#232,.T.);
#236=ORIENTED_EDGE('',*,*,#235,.T.);
#237=DIRECTION('',(0.,1.,0.));
#238=VECTOR('',#237,1.);
#239=CARTESIAN_POINT('',(200.,90.,-10.));
#240=LINE('',#239,#238);
#241=CARTESIAN_POINT('',(200.,130.,-10.));
#242=VERTEX_POINT('',#241);
#243=EDGE_CURVE('E304',#234,#242,#240,.T.);
#244=ORIENTED_EDGE('',*,*,#243,.T.);
#245=DIRECTION('',(-1.,0.,0.));
#246=VECTOR('',#245,1.);
#247=CARTESIAN_POINT('',(200.,130.,-10.));
#248=LINE('',#247,#246);
#249=CARTESIAN_POINT('',(160.,130.,-10.));
#250=VERTEX_POINT('',#249);
#251=EDGE_CURVE('E307',#242,#250,#248,.T.);
#252=ORIENTED_EDGE('',*,*,#251,.T.);
#253=DIRECTION('',(0.,1.,0.));
#254=VECTOR('',#253,1.);
#255=CARTESIAN_POINT('',(160.,130.,-10.));
#256=LINE('',#255,#254);
#257=CARTESIAN_POINT('',(160.,150.,-10.));
#258=VERTEX_POINT('',#257);
#259=EDGE_CURVE('E310',#250,#258,#256,.T.);
#260=ORIENTED_EDGE('',*,*,#259,.T.);
#261=DIRECTION('',(1.,0.,0.));
#262=VECTOR('',#261,1.);
#263=CARTESIAN_POINT('',(160.,150.,-10.));
#264=LINE('',#263,#262);
#265=CARTESIAN_POINT('',(170.,150.,-10.));
#266=VERTEX_POINT('',#265);
#267=EDGE_CURVE('E313',#258,#266,#264,.T.);
#268=ORIENTED_EDGE('',*,*,#267,.T.);
#269=DIRECTION('',(0.,1.,0.));
#270=VECTOR('',#269,1.);
#271=CARTESIAN_POINT('',(170.,150.,-10.));
#272=LINE('',#271,#270);
#273=CARTESIAN_POINT('',(170.,170.,-10.));
#274=VERTEX_POINT('',#273);
#275=EDGE_CURVE('E316',#266,#274,#272,.T.);
#276=ORIENTED_EDGE('',*,*,#275,.T.);
#277=DIRECTION('',(-1.,0.,0.));
#278=VECTOR('',#277,1.);
#279=CARTESIAN_POINT('',(170.,170.,-10.));
#280=LINE('',#279,#278);
#281=CARTESIAN_POINT('',(160.,170.,-10.));
#282=VERTEX_POINT('',#281);
#283=EDGE_CURVE('E319',#274,#282,#280,.T.);
#284=ORIENTED_EDGE('',*,*,#283,.T.);
#285=DIRECTION('',(0.,1.,0.));
#286=VECTOR('',#285,1.);
#287=CARTESIAN_POINT('',(160.,170.,-10.));
#288=LINE('',#287,#286);
#289=CARTESIAN_POINT('',(160.,180.,-10.));
#290=VERTEX_POINT('',#289);
#291=EDGE_CURVE('E322',#282,#290,#288,.T.);
#292=ORIENTED_EDGE('',*,*,#291,.T.);
#293=DIRECTION('',(-1.,0.,0.));
#294=VECTOR('',#293,1.);
#295=CARTESIAN_POINT('',(160.,180.,-10.));
#296=LINE('',#295,#294);
#297=CARTESIAN_POINT('',(90.,180.,-10.));
#298=VERTEX_POINT('',#297);
#299=EDGE_CURVE('E325',#290,#298,#296,.T.);
#300=ORIENTED_EDGE('',*,*,#299,.T.);
#301=DIRECTION('',(0.,-1.,0.));
#302=VECTOR('',#301,1.);
#303=CARTESIAN_POINT('',(90.,170.,-10.));
#304=LINE('',#303,#302);
#305=CARTESIAN_POINT('',(90.,170.,-10.));
#306=VERTEX_POINT('',#305);
#307=EDGE_CURVE('E328',#298,#306,#304,.T.);
#308=ORIENTED_EDGE('',*,*,#307,.T.);
#309=DIRECTION('',(-1.,0.,0.));
#310=VECTOR('',#309,1.);
#311=CARTESIAN_POINT('',(80.,170.,-10.));
#312=LINE('',#311,#310);
#313=CARTESIAN_POINT('',(80.,170.,-10.));
#314=VERTEX_POINT('',#313);
#315=EDGE_CURVE('E331',#306,#314,#312,.T.);
#316=ORIENTED_EDGE('',*,*,#315,.T.);
#317=DIRECTION('',(0.,-1.,0.));
#318=VECTOR('',#317,1.);
#319=CARTESIAN_POINT('',(80.,150.,-10.));
#320=LINE('',#319,#318);
#321=CARTESIAN_POINT('',(80.,150.,-10.));
#322=VERTEX_POINT('',#321);
#323=EDGE_CURVE('E334',#314,#322,#320,.T.);
#324=ORIENTED_EDGE('',*,*,#323,.T.);
#325=DIRECTION('',(1.,0.,0.));
#326=VECTOR('',#325,1.);
#327=CARTESIAN_POINT('',(90.,150.,-10.));
#328=LINE('',#327,#326);
#329=CARTESIAN_POINT('',(90.,150.,-10.));
#330=VERTEX_POINT('',#329);
#331=EDGE_CURVE('E337',#322,#330,#328,.T.);
#332=ORIENTED_EDGE('',*,*,#331,.T.);
#333=DIRECTION('',(0.,-1.,0.));
#334=VECTOR('',#333,1.);
#335=CARTESIAN_POINT('',(90.,130.,-10.));
#336=LINE('',#335,#334);
#337=CARTESIAN_POINT('',(90.,130.,-10.));
#338=VERTEX_POINT('',#337);
#339=EDGE_CURVE('E340',#330,#338,#336,.T.);
#340=ORIENTED_EDGE('',*,*,#339,.T.);
#341=DIRECTION('',(-1.,0.,0.));
#342=VECTOR('',#341,1.);
#343=CARTESIAN_POINT('',(50.,130.,-10.));
#344=LINE('',#343,#342);
#345=CARTESIAN_POINT('',(50.,130.,-10.));
#346=VERTEX_POINT('',#345);
#347=EDGE_CURVE('E343',#338,#346,#344,.T.);
#348=ORIENTED_EDGE('',*,*,#347,.T.);
#349=DIRECTION('',(0.,-1.,0.));
#350=VECTOR('',#349,1.);
#351=CARTESIAN_POINT('',(50.,90.,-10.));
#352=LINE('',#351,#350);
#353=CARTESIAN_POINT('',(50.,90.,-10.));
#354=VERTEX_POINT('',#353);
#355=EDGE_CURVE('E346',#346,#354,#352,.T.);
#356=ORIENTED_EDGE('',*,*,#355,.T.);
#357=DIRECTION('',(-1.,0.,0.));
#358=VECTOR('',#357,1.);
#359=CARTESIAN_POINT('',(40.,90.,-10.));
#360=LINE('',#359,#358);
#361=CARTESIAN_POINT('',(40.,90.,-10.));
#362=VERTEX_POINT('',#361);
#363=EDGE_CURVE('E349',#354,#362,#360,.T.);
#364=ORIENTED_EDGE('',*,*,#363,.T.);
#365=DIRECTION('',(0.,-1.,0.));
#366=VECTOR('',#365,1.);
#367=CARTESIAN_POINT('',(40.,70.,-10.));
#368=LINE('',#367,#366);
#369=CARTESIAN_POINT('',(40.,70.,-10.));
#370=VERTEX_POINT('',#369);
#371=EDGE_CURVE('E352',#362,#370,#368,.T.);
#372=ORIENTED_EDGE('',*,*,#371,.T.);
#373=DIRECTION('',(1.,0.,0.));
#374=VECTOR('',#373,1.);
#375=CARTESIAN_POINT('',(50.,70.,-10.));
#376=LINE('',#375,#374);
#377=CARTESIAN_POINT('',(50.,70.,-10.));
#378=VERTEX_POINT('',#377);
#379=EDGE_CURVE('E355',#370,#378,#376,.T.);
#380=ORIENTED_EDGE('',*,*,#379,.T.);
#381=DIRECTION('',(0.,-1.,0.));
#382=VECTOR('',#381,1.);
#383=CARTESIAN_POINT('',(50.,30.,-10.));
#384=LINE('',#383,#382);
#385=CARTESIAN_POINT('',(50.,30.,-10.));
#386=VERTEX_POINT('',#385);
#387=EDGE_CURVE('E358',#378,#386,#384,.T.);
#388=ORIENTED_EDGE('',*,*,#387,.T.);
#389=DIRECTION('',(1.,0.,0.));
#390=VECTOR('',#389,1.);
#391=CARTESIAN_POINT('',(50.,30.,-10.));
#392=LINE('',#391,#390);
#393=EDGE_CURVE('E361',#386,#208,#392,.T.);
#394=ORIENTED_EDGE('',*,*,#393,.T.);
#395=EDGE_LOOP('',(#212,#220,#228,#236,#244,#252,#260,#268,#276,#284,#292,#300,#308,#316,#324,
#332,#340,#348,#356,#364,#372,#380,#388,#394));
#396=FACE_BOUND('',#395,.T.);
#397=ORIENTED_EDGE('',*,*,#48,.F.);
#398=ORIENTED_EDGE('',*,*,#84,.F.);
#399=ORIENTED_EDGE('',*,*,#115,.F.);
#400=ORIENTED_EDGE('',*,*,#137,.F.);
#401=EDGE_LOOP('',(#397,#398,#399,#400));
#402=FACE_BOUND('',#401,.T.);
#403=ADVANCED_FACE('F446',(#158,#169,#180,#191,#202,#396,#402),#147,.T.);
#404=CARTESIAN_POINT('',(0.,200.,0.));
#405=DIRECTION('',(0.,0.,-1.));
#406=DIRECTION('',(-1.,0.,0.));
#407=AXIS2_PLACEMENT_3D('',#404,#405,#406);
#408=PLANE('',#407);
#409=CARTESIAN_POINT('',(250.,11.,0.));
#410=DIRECTION('',(0.,0.,-1.));
#411=DIRECTION('',(-1.,0.,0.));
#412=AXIS2_PLACEMENT_3D('',#409,#410,#411);
#413=CIRCLE('',#412,6.00000000000002);
#414=CARTESIAN_POINT('',(244.,11.,0.));
#415=VERTEX_POINT('',#414);
#416=EDGE_CURVE('E780',#415,#415,#413,.T.);
#417=ORIENTED_EDGE('',*,*,#416,.T.);
#418=EDGE_LOOP('',(#417));
#419=FACE_BOUND('',#418,.T.);
#420=CARTESIAN_POINT('',(20.,20.,0.));
#421=DIRECTION('',(0.,0.,-1.));
#422=DIRECTION('',(-1.,0.,0.));
#423=AXIS2_PLACEMENT_3D('',#420,#421,#422);
#424=CIRCLE('',#423,2.50000000000002);
#425=CARTESIAN_POINT('',(17.4999999999999,20.,0.));
#426=VERTEX_POINT('',#425);
#427=EDGE_CURVE('E790',#426,#426,#424,.T.);
#428=ORIENTED_EDGE('',*,*,#427,.T.);
#429=EDGE_LOOP('',(#428));
#430=FACE_BOUND('',#429,.T.);
#431=CARTESIAN_POINT('',(20.,180.,0.));
#432=DIRECTION('',(0.,0.,-1.));
#433=DIRECTION('',(-1.,0.,0.));
#434=AXIS2_PLACEMENT_3D('',#431,#432,#433);
#435=CIRCLE('',#434,2.50000000000002);
#436=CARTESIAN_POINT('',(17.4999999999999,180.,0.));
#437=VERTEX_POINT('',#436);
#438=EDGE_CURVE('E796',#437,#437,#435,.T.);
#439=ORIENTED_EDGE('',*,*,#438,.T.);
#440=EDGE_LOOP('',(#439));
#441=FACE_BOUND('',#440,.T.);
#442=CARTESIAN_POINT('',(280.,20.,0.));
#443=DIRECTION('',(0.,0.,-1.));
#444=DIRECTION('',(-1.,0.,0.));
#445=AXIS2_PLACEMENT_3D('',#442,#443,#444);
#446=CIRCLE('',#445,2.50000000000002);
#447=CARTESIAN_POINT('',(277.5,20.,0.));
#448=VERTEX_POINT('',#447);
#449=EDGE_CURVE('E802',#448,#448,#446,.T.);
#450=ORIENTED_EDGE('',*,*,#449,.T.);
#451=EDGE_LOOP('',(#450));
#452=FACE_BOUND('',#451,.T.);
#453=CARTESIAN_POINT('',(280.,180.,0.));
#454=DIRECTION('',(0.,0.,-1.));
#455=DIRECTION('',(-1.,0.,0.));
#456=AXIS2_PLACEMENT_3D('',#453,#454,#455);
#457=CIRCLE('',#456,2.50000000000002);
#458=CARTESIAN_POINT('',(277.5,180.,0.));
#459=VERTEX_POINT('',#458);
#460=EDGE_CURVE('E826',#459,#459,#457,.T.);
#461=ORIENTED_EDGE('',*,*,#460,.T.);
#462=EDGE_LOOP('',(#461));
#463=FACE_BOUND('',#462,.T.);
#464=DIRECTION('',(1.,0.,0.));
#465=VECTOR('',#464,1.);
#466=CARTESIAN_POINT('',(200.,70.,0.));
#467=LINE('',#466,#465);
#468=CARTESIAN_POINT('',(200.,70.,0.));
#469=VERTEX_POINT('',#468);
#470=CARTESIAN_POINT('',(210.,70.,0.));
#471=VERTEX_POINT('',#470);
#472=EDGE_CURVE('E222',#469,#471,#467,.T.);
#473=ORIENTED_EDGE('',*,*,#472,.F.);
#474=DIRECTION('',(0.,1.,0.));
#475=VECTOR('',#474,1.);
#476=CARTESIAN_POINT('',(200.,30.,0.));
#477=LINE('',#476,#475);
#478=CARTESIAN_POINT('',(200.,30.,0.));
#479=VERTEX_POINT('',#478);
#480=EDGE_CURVE('E50',#479,#469,#477,.T.);
#481=ORIENTED_EDGE('',*,*,#480,.F.);
#482=DIRECTION('',(1.,0.,0.));
#483=VECTOR('',#482,1.);
#484=CARTESIAN_POINT('',(50.,30.,0.));
#485=LINE('',#484,#483);
#486=CARTESIAN_POINT('',(50.,30.,0.));
#487=VERTEX_POINT('',#486);
#488=EDGE_CURVE('E292',#487,#479,#485,.T.);
#489=ORIENTED_EDGE('',*,*,#488,.F.);
#490=DIRECTION('',(0.,-1.,0.));
#491=VECTOR('',#490,1.);
#492=CARTESIAN_POINT('',(50.,30.,0.));
#493=LINE('',#492,#491);
#494=CARTESIAN_POINT('',(50.,70.,0.));
#495=VERTEX_POINT('',#494);
#496=EDGE_CURVE('E289',#495,#487,#493,.T.);
#497=ORIENTED_EDGE('',*,*,#496,.F.);
#498=DIRECTION('',(1.,0.,0.));
#499=VECTOR('',#498,1.);
#500=CARTESIAN_POINT('',(50.,70.,0.));
#501=LINE('',#500,#499);
#502=CARTESIAN_POINT('',(40.,70.,0.));
#503=VERTEX_POINT('',#502);
#504=EDGE_CURVE('E286',#503,#495,#501,.T.);
#505=ORIENTED_EDGE('',*,*,#504,.F.);
#506=DIRECTION('',(0.,-1.,0.));
#507=VECTOR('',#506,1.);
#508=CARTESIAN_POINT('',(40.,70.,0.));
#509=LINE('',#508,#507);
#510=CARTESIAN_POINT('',(40.,90.,0.));
#511=VERTEX_POINT('',#510);
#512=EDGE_CURVE('E283',#511,#503,#509,.T.);
#513=ORIENTED_EDGE('',*,*,#512,.F.);
#514=DIRECTION('',(-1.,0.,0.));
#515=VECTOR('',#514,1.);
#516=CARTESIAN_POINT('',(40.,90.,0.));
#517=LINE('',#516,#515);
#518=CARTESIAN_POINT('',(50.,90.,0.));
#519=VERTEX_POINT('',#518);
#520=EDGE_CURVE('E280',#519,#511,#517,.T.);
#521=ORIENTED_EDGE('',*,*,#520,.F.);
#522=DIRECTION('',(0.,-1.,0.));
#523=VECTOR('',#522,1.);
#524=CARTESIAN_POINT('',(50.,90.,0.));
#525=LINE('',#524,#523);
#526=CARTESIAN_POINT('',(50.,130.,0.));
#527=VERTEX_POINT('',#526);
#528=EDGE_CURVE('E277',#527,#519,#525,.T.);
#529=ORIENTED_EDGE('',*,*,#528,.F.);
#530=DIRECTION('',(-1.,0.,0.));
#531=VECTOR('',#530,1.);
#532=CARTESIAN_POINT('',(50.,130.,0.));
#533=LINE('',#532,#531);
#534=CARTESIAN_POINT('',(90.,130.,0.));
#535=VERTEX_POINT('',#534);
#536=EDGE_CURVE('E274',#535,#527,#533,.T.);
#537=ORIENTED_EDGE('',*,*,#536,.F.);
#538=DIRECTION('',(0.,-1.,0.));
#539=VECTOR('',#538,1.);
#540=CARTESIAN_POINT('',(90.,130.,0.));
#541=LINE('',#540,#539);
#542=CARTESIAN_POINT('',(90.,150.,0.));
#543=VERTEX_POINT('',#542);
#544=EDGE_CURVE('E271',#543,#535,#541,.T.);
#545=ORIENTED_EDGE('',*,*,#544,.F.);
#546=DIRECTION('',(1.,0.,0.));
#547=VECTOR('',#546,1.);
#548=CARTESIAN_POINT('',(90.,150.,0.));
#549=LINE('',#548,#547);
#550=CARTESIAN_POINT('',(80.,150.,0.));
#551=VERTEX_POINT('',#550);
#552=EDGE_CURVE('E268',#551,#543,#549,.T.);
#553=ORIENTED_EDGE('',*,*,#552,.F.);
#554=DIRECTION('',(0.,-1.,0.));
#555=VECTOR('',#554,1.);
#556=CARTESIAN_POINT('',(80.,150.,0.));
#557=LINE('',#556,#555);
#558=CARTESIAN_POINT('',(80.,170.,0.));
#559=VERTEX_POINT('',#558);
#560=EDGE_CURVE('E265',#559,#551,#557,.T.);
#561=ORIENTED_EDGE('',*,*,#560,.F.);
#562=DIRECTION('',(-1.,0.,0.));
#563=VECTOR('',#562,1.);
#564=CARTESIAN_POINT('',(80.,170.,0.));
#565=LINE('',#564,#563);
#566=CARTESIAN_POINT('',(90.,170.,0.));
#567=VERTEX_POINT('',#566);
#568=EDGE_CURVE('E262',#567,#559,#565,.T.);
#569=ORIENTED_EDGE('',*,*,#568,.F.);
#570=DIRECTION('',(0.,-1.,0.));
#571=VECTOR('',#570,1.);
#572=CARTESIAN_POINT('',(90.,170.,0.));
#573=LINE('',#572,#571);
#574=CARTESIAN_POINT('',(90.,180.,0.));
#575=VERTEX_POINT('',#574);
#576=EDGE_CURVE('E259',#575,#567,#573,.T.);
#577=ORIENTED_EDGE('',*,*,#576,.F.);
#578=DIRECTION('',(-1.,0.,0.));
#579=VECTOR('',#578,1.);
#580=CARTESIAN_POINT('',(160.,180.,0.));
#581=LINE('',#580,#579);
#582=CARTESIAN_POINT('',(160.,180.,0.));
#583=VERTEX_POINT('',#582);
#584=EDGE_CURVE('E256',#583,#575,#581,.T.);
#585=ORIENTED_EDGE('',*,*,#584,.F.);
#586=DIRECTION('',(0.,1.,0.));
#587=VECTOR('',#586,1.);
#588=CARTESIAN_POINT('',(160.,170.,0.));
#589=LINE('',#588,#587);
#590=CARTESIAN_POINT('',(160.,170.,0.));
#591=VERTEX_POINT('',#590);
#592=EDGE_CURVE('E253',#591,#583,#589,.T.);
#593=ORIENTED_EDGE('',*,*,#592,.F.);
#594=DIRECTION('',(-1.,0.,0.));
#595=VECTOR('',#594,1.);
#596=CARTESIAN_POINT('',(170.,170.,0.));
#597=LINE('',#596,#595);
#598=CARTESIAN_POINT('',(170.,170.,0.));
#599=VERTEX_POINT('',#598);
#600=EDGE_CURVE('E250',#599,#591,#597,.T.);
#601=ORIENTED_EDGE('',*,*,#600,.F.);
#602=DIRECTION('',(0.,1.,0.));
#603=VECTOR('',#602,1.);
#604=CARTESIAN_POINT('',(170.,150.,0.));
#605=LINE('',#604,#603);
#606=CARTESIAN_POINT('',(170.,150.,0.));
#607=VERTEX_POINT('',#606);
#608=EDGE_CURVE('E247',#607,#599,#605,.T.);
#609=ORIENTED_EDGE('',*,*,#608,.F.);
#610=DIRECTION('',(1.,0.,0.));
#611=VECTOR('',#610,1.);
#612=CARTESIAN_POINT('',(160.,150.,0.));
#613=LINE('',#612,#611);
#614=CARTESIAN_POINT('',(160.,150.,0.));
#615=VERTEX_POINT('',#614);
#616=EDGE_CURVE('E244',#615,#607,#613,.T.);
#617=ORIENTED_EDGE('',*,*,#616,.F.);
#618=DIRECTION('',(0.,1.,0.));
#619=VECTOR('',#618,1.);
#620=CARTESIAN_POINT('',(160.,130.,0.));
#621=LINE('',#620,#619);
#622=CARTESIAN_POINT('',(160.,130.,0.));
#623=VERTEX_POINT('',#622);
#624=EDGE_CURVE('E241',#623,#615,#621,.T.);
#625=ORIENTED_EDGE('',*,*,#624,.F.);
#626=DIRECTION('',(-1.,0.,0.));
#627=VECTOR('',#626,1.);
#628=CARTESIAN_POINT('',(200.,130.,0.));
#629=LINE('',#628,#627);
#630=CARTESIAN_POINT('',(200.,130.,0.));
#631=VERTEX_POINT('',#630);
#632=EDGE_CURVE('E238',#631,#623,#629,.T.);
#633=ORIENTED_EDGE('',*,*,#632,.F.);
#634=DIRECTION('',(0.,1.,0.));
#635=VECTOR('',#634,1.);
#636=CARTESIAN_POINT('',(200.,90.,0.));
#637=LINE('',#636,#635);
#638=CARTESIAN_POINT('',(200.,90.,0.));
#639=VERTEX_POINT('',#638);
#640=EDGE_CURVE('E232',#639,#631,#637,.T.);
#641=ORIENTED_EDGE('',*,*,#640,.F.);
#642=DIRECTION('',(-1.,0.,0.));
#643=VECTOR('',#642,1.);
#644=CARTESIAN_POINT('',(210.,90.,0.));
#645=LINE('',#644,#643);
#646=CARTESIAN_POINT('',(210.,90.,0.));
#647=VERTEX_POINT('',#646);
#648=EDGE_CURVE('E230',#647,#639,#645,.T.);
#649=ORIENTED_EDGE('',*,*,#648,.F.);
#650=DIRECTION('',(0.,1.,0.));
#651=VECTOR('',#650,1.);
#652=CARTESIAN_POINT('',(210.,70.,0.));
#653=LINE('',#652,#651);
#654=EDGE_CURVE('E213',#471,#647,#653,.T.);
#655=ORIENTED_EDGE('',*,*,#654,.F.);
#656=EDGE_LOOP('',(#473,#481,#489,#497,#505,#513,#521,#529,#537,#545,#553,#561,#569,#577,#585,
#593,#601,#609,#617,#625,#633,#641,#649,#655));
#657=FACE_BOUND('',#656,.T.);
#658=ORIENTED_EDGE('',*,*,#32,.T.);
#659=ORIENTED_EDGE('',*,*,#130,.T.);
#660=ORIENTED_EDGE('',*,*,#101,.T.);
#661=ORIENTED_EDGE('',*,*,#70,.T.);
#662=EDGE_LOOP('',(#658,#659,#660,#661));
#663=FACE_BOUND('',#662,.T.);
#664=ADVANCED_FACE('F226',(#419,#430,#441,#452,#463,#657,#663),#408,.F.);
#665=CARTESIAN_POINT('',(200.,30.,-10.));
#666=DIRECTION('',(1.,0.,0.));
#667=DIRECTION('',(0.,0.,-1.));
#668=AXIS2_PLACEMENT_3D('',#665,#666,#667);
#669=PLANE('',#668);
#670=ORIENTED_EDGE('',*,*,#480,.T.);
#671=DIRECTION('',(0.,0.,1.));
#672=VECTOR('',#671,1.);
#673=CARTESIAN_POINT('',(200.,70.,-10.));
#674=LINE('',#673,#672);
#675=EDGE_CURVE('E219',#210,#469,#674,.T.);
#676=ORIENTED_EDGE('',*,*,#675,.F.);
#677=ORIENTED_EDGE('',*,*,#211,.F.);
#678=DIRECTION('',(0.,0.,1.));
#679=VECTOR('',#678,1.);
#680=CARTESIAN_POINT('',(200.,30.,-10.));
#681=LINE('',#680,#679);
#682=EDGE_CURVE('E364',#208,#479,#681,.T.);
#683=ORIENTED_EDGE('',*,*,#682,.T.);
#684=EDGE_LOOP('',(#670,#676,#677,#683));
#685=FACE_BOUND('',#684,.T.);
#686=ADVANCED_FACE('F486',(#685),#669,.F.);
#687=CARTESIAN_POINT('',(50.,30.,-10.));
#688=DIRECTION('',(0.,-1.,0.));
#689=DIRECTION('',(0.,0.,-1.));
#690=AXIS2_PLACEMENT_3D('',#687,#688,#689);
#691=PLANE('',#690);
#692=ORIENTED_EDGE('',*,*,#488,.T.);
#693=ORIENTED_EDGE('',*,*,#682,.F.);
#694=ORIENTED_EDGE('',*,*,#393,.F.);
#695=DIRECTION('',(0.,0.,1.));
#696=VECTOR('',#695,1.);
#697=CARTESIAN_POINT('',(50.,30.,-10.));
#698=LINE('',#697,#696);
#699=EDGE_CURVE('E367',#386,#487,#698,.T.);
#700=ORIENTED_EDGE('',*,*,#699,.T.);
#701=EDGE_LOOP('',(#692,#693,#694,#700));
#702=FACE_BOUND('',#701,.T.);
#703=ADVANCED_FACE('F494',(#702),#691,.F.);
#704=CARTESIAN_POINT('',(50.,30.,-10.));
#705=DIRECTION('',(-1.,0.,0.));
#706=DIRECTION('',(0.,-1.,0.));
#707=AXIS2_PLACEMENT_3D('',#704,#705,#706);
#708=PLANE('',#707);
#709=ORIENTED_EDGE('',*,*,#496,.T.);
#710=ORIENTED_EDGE('',*,*,#699,.F.);
#711=ORIENTED_EDGE('',*,*,#387,.F.);
#712=DIRECTION('',(0.,0.,1.));
#713=VECTOR('',#712,1.);
#714=CARTESIAN_POINT('',(50.,70.,-10.));
#715=LINE('',#714,#713);
#716=EDGE_CURVE('E369',#378,#495,#715,.T.);
#717=ORIENTED_EDGE('',*,*,#716,.T.);
#718=EDGE_LOOP('',(#709,#710,#711,#717));
#719=FACE_BOUND('',#718,.T.);
#720=ADVANCED_FACE('F501',(#719),#708,.F.);
#721=CARTESIAN_POINT('',(50.,70.,-10.));
#722=DIRECTION('',(0.,-1.,0.));
#723=DIRECTION('',(0.,0.,-1.));
#724=AXIS2_PLACEMENT_3D('',#721,#722,#723);
#725=PLANE('',#724);
#726=ORIENTED_EDGE('',*,*,#504,.T.);
#727=ORIENTED_EDGE('',*,*,#716,.F.);
#728=ORIENTED_EDGE('',*,*,#379,.F.);
#729=DIRECTION('',(0.,0.,1.));
#730=VECTOR('',#729,1.);
#731=CARTESIAN_POINT('',(40.,70.,-10.));
#732=LINE('',#731,#730);
#733=EDGE_CURVE('E371',#370,#503,#732,.T.);
#734=ORIENTED_EDGE('',*,*,#733,.T.);
#735=EDGE_LOOP('',(#726,#727,#728,#734));
#736=FACE_BOUND('',#735,.T.);
#737=ADVANCED_FACE('F509',(#736),#725,.F.);
#738=CARTESIAN_POINT('',(40.,70.,-10.));
#739=DIRECTION('',(-1.,0.,0.));
#740=DIRECTION('',(0.,0.,1.));
#741=AXIS2_PLACEMENT_3D('',#738,#739,#740);
#742=PLANE('',#741);
#743=ORIENTED_EDGE('',*,*,#512,.T.);
#744=ORIENTED_EDGE('',*,*,#733,.F.);
#745=ORIENTED_EDGE('',*,*,#371,.F.);
#746=DIRECTION('',(0.,0.,1.));
#747=VECTOR('',#746,1.);
#748=CARTESIAN_POINT('',(40.,90.,-10.));
#749=LINE('',#748,#747);
#750=EDGE_CURVE('E373',#362,#511,#749,.T.);
#751=ORIENTED_EDGE('',*,*,#750,.T.);
#752=EDGE_LOOP('',(#743,#744,#745,#751));
#753=FACE_BOUND('',#752,.T.);
#754=ADVANCED_FACE('F517',(#753),#742,.F.);
#755=CARTESIAN_POINT('',(40.,90.,-10.));
#756=DIRECTION('',(0.,1.,0.));
#757=DIRECTION('',(0.,0.,1.));
#758=AXIS2_PLACEMENT_3D('',#755,#756,#757);
#759=PLANE('',#758);
#760=ORIENTED_EDGE('',*,*,#520,.T.);
#761=ORIENTED_EDGE('',*,*,#750,.F.);
#762=ORIENTED_EDGE('',*,*,#363,.F.);
#763=DIRECTION('',(0.,0.,1.));
#764=VECTOR('',#763,1.);
#765=CARTESIAN_POINT('',(50.,90.,-10.));
#766=LINE('',#765,#764);
#767=EDGE_CURVE('E375',#354,#519,#766,.T.);
#768=ORIENTED_EDGE('',*,*,#767,.T.);
#769=EDGE_LOOP('',(#760,#761,#762,#768));
#770=FACE_BOUND('',#769,.T.);
#771=ADVANCED_FACE('F525',(#770),#759,.F.);
#772=CARTESIAN_POINT('',(50.,90.,-10.));
#773=DIRECTION('',(-1.,0.,0.));
#774=DIRECTION('',(0.,0.,1.));
#775=AXIS2_PLACEMENT_3D('',#772,#773,#774);
#776=PLANE('',#775);
#777=ORIENTED_EDGE('',*,*,#528,.T.);
#778=ORIENTED_EDGE('',*,*,#767,.F.);
#779=ORIENTED_EDGE('',*,*,#355,.F.);
#780=DIRECTION('',(0.,0.,1.));
#781=VECTOR('',#780,1.);
#782=CARTESIAN_POINT('',(50.,130.,-10.));
#783=LINE('',#782,#781);
#784=EDGE_CURVE('E377',#346,#527,#783,.T.);
#785=ORIENTED_EDGE('',*,*,#784,.T.);
#786=EDGE_LOOP('',(#777,#778,#779,#785));
#787=FACE_BOUND('',#786,.T.);
#788=ADVANCED_FACE('F533',(#787),#776,.F.);
#789=CARTESIAN_POINT('',(50.,130.,-10.));
#790=DIRECTION('',(0.,1.,0.));
#791=DIRECTION('',(-1.,0.,0.));
#792=AXIS2_PLACEMENT_3D('',#789,#790,#791);
#793=PLANE('',#792);
#794=ORIENTED_EDGE('',*,*,#536,.T.);
#795=ORIENTED_EDGE('',*,*,#784,.F.);
#796=ORIENTED_EDGE('',*,*,#347,.F.);
#797=DIRECTION('',(0.,0.,1.));
#798=VECTOR('',#797,1.);
#799=CARTESIAN_POINT('',(90.,130.,-10.));
#800=LINE('',#799,#798);
#801=EDGE_CURVE('E379',#338,#535,#800,.T.);
#802=ORIENTED_EDGE('',*,*,#801,.T.);
#803=EDGE_LOOP('',(#794,#795,#796,#802));
#804=FACE_BOUND('',#803,.T.);
#805=ADVANCED_FACE('F541',(#804),#793,.F.);
#806=CARTESIAN_POINT('',(90.,130.,-10.));
#807=DIRECTION('',(-1.,0.,0.));
#808=DIRECTION('',(0.,0.,1.));
#809=AXIS2_PLACEMENT_3D('',#806,#807,#808);
#810=PLANE('',#809);
#811=ORIENTED_EDGE('',*,*,#544,.T.);
#812=ORIENTED_EDGE('',*,*,#801,.F.);
#813=ORIENTED_EDGE('',*,*,#339,.F.);
#814=DIRECTION('',(0.,0.,1.));
#815=VECTOR('',#814,1.);
#816=CARTESIAN_POINT('',(90.,150.,-10.));
#817=LINE('',#816,#815);
#818=EDGE_CURVE('E381',#330,#543,#817,.T.);
#819=ORIENTED_EDGE('',*,*,#818,.T.);
#820=EDGE_LOOP('',(#811,#812,#813,#819));
#821=FACE_BOUND('',#820,.T.);
#822=ADVANCED_FACE('F549',(#821),#810,.F.);
#823=CARTESIAN_POINT('',(90.,150.,-10.));
#824=DIRECTION('',(0.,-1.,0.));
#825=DIRECTION('',(0.,0.,-1.));
#826=AXIS2_PLACEMENT_3D('',#823,#824,#825);
#827=PLANE('',#826);
#828=ORIENTED_EDGE('',*,*,#552,.T.);
#829=ORIENTED_EDGE('',*,*,#818,.F.);
#830=ORIENTED_EDGE('',*,*,#331,.F.);
#831=DIRECTION('',(0.,0.,1.));
#832=VECTOR('',#831,1.);
#833=CARTESIAN_POINT('',(80.,150.,-10.));
#834=LINE('',#833,#832);
#835=EDGE_CURVE('E383',#322,#551,#834,.T.);
#836=ORIENTED_EDGE('',*,*,#835,.T.);
#837=EDGE_LOOP('',(#828,#829,#830,#836));
#838=FACE_BOUND('',#837,.T.);
#839=ADVANCED_FACE('F557',(#838),#827,.F.);
#840=CARTESIAN_POINT('',(80.,150.,-10.));
#841=DIRECTION('',(-1.,0.,0.));
#842=DIRECTION('',(0.,0.,1.));
#843=AXIS2_PLACEMENT_3D('',#840,#841,#842);
#844=PLANE('',#843);
#845=ORIENTED_EDGE('',*,*,#560,.T.);
#846=ORIENTED_EDGE('',*,*,#835,.F.);
#847=ORIENTED_EDGE('',*,*,#323,.F.);
#848=DIRECTION('',(0.,0.,1.));
#849=VECTOR('',#848,1.);
#850=CARTESIAN_POINT('',(80.,170.,-10.));
#851=LINE('',#850,#849);
#852=EDGE_CURVE('E385',#314,#559,#851,.T.);
#853=ORIENTED_EDGE('',*,*,#852,.T.);
#854=EDGE_LOOP('',(#845,#846,#847,#853));
#855=FACE_BOUND('',#854,.T.);
#856=ADVANCED_FACE('F565',(#855),#844,.F.);
#857=CARTESIAN_POINT('',(80.,170.,-10.));
#858=DIRECTION('',(0.,1.,0.));
#859=DIRECTION('',(0.,0.,1.));
#860=AXIS2_PLACEMENT_3D('',#857,#858,#859);
#861=PLANE('',#860);
#862=ORIENTED_EDGE('',*,*,#568,.T.);
#863=ORIENTED_EDGE('',*,*,#852,.F.);
#864=ORIENTED_EDGE('',*,*,#315,.F.);
#865=DIRECTION('',(0.,0.,1.));
#866=VECTOR('',#865,1.);
#867=CARTESIAN_POINT('',(90.,170.,-10.));
#868=LINE('',#867,#866);
#869=EDGE_CURVE('E387',#306,#567,#868,.T.);
#870=ORIENTED_EDGE('',*,*,#869,.T.);
#871=EDGE_LOOP('',(#862,#863,#864,#870));
#872=FACE_BOUND('',#871,.T.);
#873=ADVANCED_FACE('F573',(#872),#861,.F.);
#874=CARTESIAN_POINT('',(90.,170.,-10.));
#875=DIRECTION('',(-1.,0.,0.));
#876=DIRECTION('',(0.,-1.,0.));
#877=AXIS2_PLACEMENT_3D('',#874,#875,#876);
#878=PLANE('',#877);
#879=ORIENTED_EDGE('',*,*,#576,.T.);
#880=ORIENTED_EDGE('',*,*,#869,.F.);
#881=ORIENTED_EDGE('',*,*,#307,.F.);
#882=DIRECTION('',(0.,0.,1.));
#883=VECTOR('',#882,1.);
#884=CARTESIAN_POINT('',(90.,180.,-10.));
#885=LINE('',#884,#883);
#886=EDGE_CURVE('E389',#298,#575,#885,.T.);
#887=ORIENTED_EDGE('',*,*,#886,.T.);
#888=EDGE_LOOP('',(#879,#880,#881,#887));
#889=FACE_BOUND('',#888,.T.);
#890=ADVANCED_FACE('F581',(#889),#878,.F.);
#891=CARTESIAN_POINT('',(160.,180.,-10.));
#892=DIRECTION('',(0.,1.,0.));
#893=DIRECTION('',(0.,0.,1.));
#894=AXIS2_PLACEMENT_3D('',#891,#892,#893);
#895=PLANE('',#894);
#896=ORIENTED_EDGE('',*,*,#584,.T.);
#897=ORIENTED_EDGE('',*,*,#886,.F.);
#898=ORIENTED_EDGE('',*,*,#299,.F.);
#899=DIRECTION('',(0.,0.,1.));
#900=VECTOR('',#899,1.);
#901=CARTESIAN_POINT('',(160.,180.,-10.));
#902=LINE('',#901,#900);
#903=EDGE_CURVE('E391',#290,#583,#902,.T.);
#904=ORIENTED_EDGE('',*,*,#903,.T.);
#905=EDGE_LOOP('',(#896,#897,#898,#904));
#906=FACE_BOUND('',#905,.T.);
#907=ADVANCED_FACE('F589',(#906),#895,.F.);
#908=CARTESIAN_POINT('',(160.,170.,-10.));
#909=DIRECTION('',(1.,0.,0.));
#910=DIRECTION('',(0.,1.,0.));
#911=AXIS2_PLACEMENT_3D('',#908,#909,#910);
#912=PLANE('',#911);
#913=ORIENTED_EDGE('',*,*,#592,.T.);
#914=ORIENTED_EDGE('',*,*,#903,.F.);
#915=ORIENTED_EDGE('',*,*,#291,.F.);
#916=DIRECTION('',(0.,0.,1.));
#917=VECTOR('',#916,1.);
#918=CARTESIAN_POINT('',(160.,170.,-10.));
#919=LINE('',#918,#917);
#920=EDGE_CURVE('E393',#282,#591,#919,.T.);
#921=ORIENTED_EDGE('',*,*,#920,.T.);
#922=EDGE_LOOP('',(#913,#914,#915,#921));
#923=FACE_BOUND('',#922,.T.);
#924=ADVANCED_FACE('F597',(#923),#912,.F.);
#925=CARTESIAN_POINT('',(170.,170.,-10.));
#926=DIRECTION('',(0.,1.,0.));
#927=DIRECTION('',(0.,0.,1.));
#928=AXIS2_PLACEMENT_3D('',#925,#926,#927);
#929=PLANE('',#928);
#930=ORIENTED_EDGE('',*,*,#600,.T.);
#931=ORIENTED_EDGE('',*,*,#920,.F.);
#932=ORIENTED_EDGE('',*,*,#283,.F.);
#933=DIRECTION('',(0.,0.,1.));
#934=VECTOR('',#933,1.);
#935=CARTESIAN_POINT('',(170.,170.,-10.));
#936=LINE('',#935,#934);
#937=EDGE_CURVE('E395',#274,#599,#936,.T.);
#938=ORIENTED_EDGE('',*,*,#937,.T.);
#939=EDGE_LOOP('',(#930,#931,#932,#938));
#940=FACE_BOUND('',#939,.T.);
#941=ADVANCED_FACE('F605',(#940),#929,.F.);
#942=CARTESIAN_POINT('',(170.,150.,-10.));
#943=DIRECTION('',(1.,0.,0.));
#944=DIRECTION('',(0.,0.,-1.));
#945=AXIS2_PLACEMENT_3D('',#942,#943,#944);
#946=PLANE('',#945);
#947=ORIENTED_EDGE('',*,*,#608,.T.);
#948=ORIENTED_EDGE('',*,*,#937,.F.);
#949=ORIENTED_EDGE('',*,*,#275,.F.);
#950=DIRECTION('',(0.,0.,1.));
#951=VECTOR('',#950,1.);
#952=CARTESIAN_POINT('',(170.,150.,-10.));
#953=LINE('',#952,#951);
#954=EDGE_CURVE('E397',#266,#607,#953,.T.);
#955=ORIENTED_EDGE('',*,*,#954,.T.);
#956=EDGE_LOOP('',(#947,#948,#949,#955));
#957=FACE_BOUND('',#956,.T.);
#958=ADVANCED_FACE('F613',(#957),#946,.F.);
#959=CARTESIAN_POINT('',(160.,150.,-10.));
#960=DIRECTION('',(0.,-1.,0.));
#961=DIRECTION('',(0.,0.,-1.));
#962=AXIS2_PLACEMENT_3D('',#959,#960,#961);
#963=PLANE('',#962);
#964=ORIENTED_EDGE('',*,*,#616,.T.);
#965=ORIENTED_EDGE('',*,*,#954,.F.);
#966=ORIENTED_EDGE('',*,*,#267,.F.);
#967=DIRECTION('',(0.,0.,1.));
#968=VECTOR('',#967,1.);
#969=CARTESIAN_POINT('',(160.,150.,-10.));
#970=LINE('',#969,#968);
#971=EDGE_CURVE('E399',#258,#615,#970,.T.);
#972=ORIENTED_EDGE('',*,*,#971,.T.);
#973=EDGE_LOOP('',(#964,#965,#966,#972));
#974=FACE_BOUND('',#973,.T.);
#975=ADVANCED_FACE('F621',(#974),#963,.F.);
#976=CARTESIAN_POINT('',(160.,130.,-10.));
#977=DIRECTION('',(1.,0.,0.));
#978=DIRECTION('',(0.,0.,-1.));
#979=AXIS2_PLACEMENT_3D('',#976,#977,#978);
#980=PLANE('',#979);
#981=ORIENTED_EDGE('',*,*,#624,.T.);
#982=ORIENTED_EDGE('',*,*,#971,.F.);
#983=ORIENTED_EDGE('',*,*,#259,.F.);
#984=DIRECTION('',(0.,0.,1.));
#985=VECTOR('',#984,1.);
#986=CARTESIAN_POINT('',(160.,130.,-10.));
#987=LINE('',#986,#985);
#988=EDGE_CURVE('E401',#250,#623,#987,.T.);
#989=ORIENTED_EDGE('',*,*,#988,.T.);
#990=EDGE_LOOP('',(#981,#982,#983,#989));
#991=FACE_BOUND('',#990,.T.);
#992=ADVANCED_FACE('F629',(#991),#980,.F.);
#993=CARTESIAN_POINT('',(200.,130.,-10.));
#994=DIRECTION('',(0.,1.,0.));
#995=DIRECTION('',(0.,0.,1.));
#996=AXIS2_PLACEMENT_3D('',#993,#994,#995);
#997=PLANE('',#996);
#998=ORIENTED_EDGE('',*,*,#632,.T.);
#999=ORIENTED_EDGE('',*,*,#988,.F.);
#1000=ORIENTED_EDGE('',*,*,#251,.F.);
#1001=DIRECTION('',(0.,0.,1.));
#1002=VECTOR('',#1001,1.);
#1003=CARTESIAN_POINT('',(200.,130.,-10.));
#1004=LINE('',#1003,#1002);
#1005=EDGE_CURVE('E403',#242,#631,#1004,.T.);
#1006=ORIENTED_EDGE('',*,*,#1005,.T.);
#1007=EDGE_LOOP('',(#998,#999,#1000,#1006));
#1008=FACE_BOUND('',#1007,.T.);
#1009=ADVANCED_FACE('F637',(#1008),#997,.F.);
#1010=CARTESIAN_POINT('',(200.,90.,-10.));
#1011=DIRECTION('',(1.,0.,0.));
#1012=DIRECTION('',(0.,0.,-1.));
#1013=AXIS2_PLACEMENT_3D('',#1010,#1011,#1012);
#1014=PLANE('',#1013);
#1015=ORIENTED_EDGE('',*,*,#640,.T.);
#1016=ORIENTED_EDGE('',*,*,#1005,.F.);
#1017=ORIENTED_EDGE('',*,*,#243,.F.);
#1018=DIRECTION('',(0.,0.,1.));
#1019=VECTOR('',#1018,1.);
#1020=CARTESIAN_POINT('',(200.,90.,-10.));
#1021=LINE('',#1020,#1019);
#1022=EDGE_CURVE('E405',#234,#639,#1021,.T.);
#1023=ORIENTED_EDGE('',*,*,#1022,.T.);
#1024=EDGE_LOOP('',(#1015,#1016,#1017,#1023));
#1025=FACE_BOUND('',#1024,.T.);
#1026=ADVANCED_FACE('F645',(#1025),#1014,.F.);
#1027=CARTESIAN_POINT('',(210.,90.,-10.));
#1028=DIRECTION('',(0.,1.,0.));
#1029=DIRECTION('',(0.,0.,1.));
#1030=AXIS2_PLACEMENT_3D('',#1027,#1028,#1029);
#1031=PLANE('',#1030);
#1032=ORIENTED_EDGE('',*,*,#648,.T.);
#1033=ORIENTED_EDGE('',*,*,#1022,.F.);
#1034=ORIENTED_EDGE('',*,*,#235,.F.);
#1035=DIRECTION('',(0.,0.,1.));
#1036=VECTOR('',#1035,1.);
#1037=CARTESIAN_POINT('',(210.,90.,-10.));
#1038=LINE('',#1037,#1036);
#1039=EDGE_CURVE('E218',#226,#647,#1038,.T.);
#1040=ORIENTED_EDGE('',*,*,#1039,.T.);
#1041=EDGE_LOOP('',(#1032,#1033,#1034,#1040));
#1042=FACE_BOUND('',#1041,.T.);
#1043=ADVANCED_FACE('F653',(#1042),#1031,.F.);
#1044=CARTESIAN_POINT('',(210.,70.,-10.));
#1045=DIRECTION('',(1.,0.,0.));
#1046=DIRECTION('',(0.,0.,-1.));
#1047=AXIS2_PLACEMENT_3D('',#1044,#1045,#1046);
#1048=PLANE('',#1047);
#1049=ORIENTED_EDGE('',*,*,#654,.T.);
#1050=ORIENTED_EDGE('',*,*,#1039,.F.);
#1051=ORIENTED_EDGE('',*,*,#227,.F.);
#1052=DIRECTION('',(0.,0.,1.));
#1053=VECTOR('',#1052,1.);
#1054=CARTESIAN_POINT('',(210.,70.,-10.));
#1055=LINE('',#1054,#1053);
#1056=EDGE_CURVE('E209',#218,#471,#1055,.T.);
#1057=ORIENTED_EDGE('',*,*,#1056,.T.);
#1058=EDGE_LOOP('',(#1049,#1050,#1051,#1057));
#1059=FACE_BOUND('',#1058,.T.);
#1060=ADVANCED_FACE('F211',(#1059),#1048,.F.);
#1061=CARTESIAN_POINT('',(200.,70.,-10.));
#1062=DIRECTION('',(0.,-1.,0.));
#1063=DIRECTION('',(0.,0.,-1.));
#1064=AXIS2_PLACEMENT_3D('',#1061,#1062,#1063);
#1065=PLANE('',#1064);
#1066=ORIENTED_EDGE('',*,*,#472,.T.);
#1067=ORIENTED_EDGE('',*,*,#1056,.F.);
#1068=ORIENTED_EDGE('',*,*,#219,.F.);
#1069=ORIENTED_EDGE('',*,*,#675,.T.);
#1070=EDGE_LOOP('',(#1066,#1067,#1068,#1069));
#1071=FACE_BOUND('',#1070,.T.);
#1072=ADVANCED_FACE('F223',(#1071),#1065,.F.);
#1073=CARTESIAN_POINT('',(280.,180.,-5.));
#1074=DIRECTION('',(0.,0.,-1.));
#1075=DIRECTION('',(-1.,0.,0.));
#1076=AXIS2_PLACEMENT_3D('',#1073,#1074,#1075);
#1077=CYLINDRICAL_SURFACE('',#1076,4.99999999999999);
#1078=CARTESIAN_POINT('',(280.,180.,-5.));
#1079=DIRECTION('',(0.,0.,-1.));
#1080=DIRECTION('',(-1.,0.,0.));
#1081=AXIS2_PLACEMENT_3D('',#1078,#1079,#1080);
#1082=CIRCLE('',#1081,4.99999999999999);
#1083=CARTESIAN_POINT('',(275.,180.,-5.));
#1084=VERTEX_POINT('',#1083);
#1085=EDGE_CURVE('E832',#1084,#1084,#1082,.T.);
#1086=ORIENTED_EDGE('',*,*,#1085,.F.);
#1087=EDGE_LOOP('',(#1086));
#1088=FACE_BOUND('',#1087,.T.);
#1089=ORIENTED_EDGE('',*,*,#199,.T.);
#1090=EDGE_LOOP('',(#1089));
#1091=FACE_BOUND('',#1090,.T.);
#1092=ADVANCED_FACE('F674',(#1088,#1091),#1077,.F.);
#1093=CARTESIAN_POINT('',(280.,180.,-5.));
#1094=DIRECTION('',(0.,0.,-1.));
#1095=DIRECTION('',(-1.,0.,0.));
#1096=AXIS2_PLACEMENT_3D('',#1093,#1094,#1095);
#1097=PLANE('',#1096);
#1098=CARTESIAN_POINT('',(280.,180.,-5.));
#1099=DIRECTION('',(0.,0.,-1.));
#1100=DIRECTION('',(-1.,0.,0.));
#1101=AXIS2_PLACEMENT_3D('',#1098,#1099,#1100);
#1102=CIRCLE('',#1101,2.50000000000002);
#1103=CARTESIAN_POINT('',(277.5,180.,-5.));
#1104=VERTEX_POINT('',#1103);
#1105=EDGE_CURVE('E823',#1104,#1104,#1102,.T.);
#1106=ORIENTED_EDGE('',*,*,#1105,.F.);
#1107=EDGE_LOOP('',(#1106));
#1108=FACE_BOUND('',#1107,.T.);
#1109=ORIENTED_EDGE('',*,*,#1085,.T.);
#1110=EDGE_LOOP('',(#1109));
#1111=FACE_BOUND('',#1110,.T.);
#1112=ADVANCED_FACE('F681',(#1108,#1111),#1097,.T.);
#1113=CARTESIAN_POINT('',(280.,180.,0.));
#1114=DIRECTION('',(0.,0.,-1.));
#1115=DIRECTION('',(-1.,0.,0.));
#1116=AXIS2_PLACEMENT_3D('',#1113,#1114,#1115);
#1117=CYLINDRICAL_SURFACE('',#1116,2.50000000000002);
#1118=ORIENTED_EDGE('',*,*,#460,.F.);
#1119=EDGE_LOOP('',(#1118));
#1120=FACE_BOUND('',#1119,.T.);
#1121=ORIENTED_EDGE('',*,*,#1105,.T.);
#1122=EDGE_LOOP('',(#1121));
#1123=FACE_BOUND('',#1122,.T.);
#1124=ADVANCED_FACE('F689',(#1120,#1123),#1117,.F.);
#1125=CARTESIAN_POINT('',(280.,20.,-5.));
#1126=DIRECTION('',(0.,0.,-1.));
#1127=DIRECTION('',(-1.,0.,0.));
#1128=AXIS2_PLACEMENT_3D('',#1125,#1126,#1127);
#1129=CYLINDRICAL_SURFACE('',#1128,4.99999999999999);
#1130=CARTESIAN_POINT('',(280.,20.,-5.));
#1131=DIRECTION('',(0.,0.,-1.));
#1132=DIRECTION('',(-1.,0.,0.));
#1133=AXIS2_PLACEMENT_3D('',#1130,#1131,#1132);
#1134=CIRCLE('',#1133,4.99999999999999);
#1135=CARTESIAN_POINT('',(275.,20.,-5.));
#1136=VERTEX_POINT('',#1135);
#1137=EDGE_CURVE('E820',#1136,#1136,#1134,.T.);
#1138=ORIENTED_EDGE('',*,*,#1137,.F.);
#1139=EDGE_LOOP('',(#1138));
#1140=FACE_BOUND('',#1139,.T.);
#1141=ORIENTED_EDGE('',*,*,#188,.T.);
#1142=EDGE_LOOP('',(#1141));
#1143=FACE_BOUND('',#1142,.T.);
#1144=ADVANCED_FACE('F697',(#1140,#1143),#1129,.F.);
#1145=CARTESIAN_POINT('',(280.,20.,-5.));
#1146=DIRECTION('',(0.,0.,-1.));
#1147=DIRECTION('',(-1.,0.,0.));
#1148=AXIS2_PLACEMENT_3D('',#1145,#1146,#1147);
#1149=PLANE('',#1148);
#1150=CARTESIAN_POINT('',(280.,20.,-5.));
#1151=DIRECTION('',(0.,0.,-1.));
#1152=DIRECTION('',(-1.,0.,0.));
#1153=AXIS2_PLACEMENT_3D('',#1150,#1151,#1152);
#1154=CIRCLE('',#1153,2.50000000000002);
#1155=CARTESIAN_POINT('',(277.5,20.,-5.));
#1156=VERTEX_POINT('',#1155);
#1157=EDGE_CURVE('E799',#1156,#1156,#1154,.T.);
#1158=ORIENTED_EDGE('',*,*,#1157,.F.);
#1159=EDGE_LOOP('',(#1158));
#1160=FACE_BOUND('',#1159,.T.);
#1161=ORIENTED_EDGE('',*,*,#1137,.T.);
#1162=EDGE_LOOP('',(#1161));
#1163=FACE_BOUND('',#1162,.T.);
#1164=ADVANCED_FACE('F705',(#1160,#1163),#1149,.T.);
#1165=CARTESIAN_POINT('',(20.,180.,-5.));
#1166=DIRECTION('',(0.,0.,-1.));
#1167=DIRECTION('',(-1.,0.,0.));
#1168=AXIS2_PLACEMENT_3D('',#1165,#1166,#1167);
#1169=CYLINDRICAL_SURFACE('',#1168,4.99999999999999);
#1170=CARTESIAN_POINT('',(20.,180.,-5.));
#1171=DIRECTION('',(0.,0.,-1.));
#1172=DIRECTION('',(-1.,0.,0.));
#1173=AXIS2_PLACEMENT_3D('',#1170,#1171,#1172);
#1174=CIRCLE('',#1173,4.99999999999999);
#1175=CARTESIAN_POINT('',(15.,180.,-5.));
#1176=VERTEX_POINT('',#1175);
#1177=EDGE_CURVE('E814',#1176,#1176,#1174,.T.);
#1178=ORIENTED_EDGE('',*,*,#1177,.F.);
#1179=EDGE_LOOP('',(#1178));
#1180=FACE_BOUND('',#1179,.T.);
#1181=ORIENTED_EDGE('',*,*,#177,.T.);
#1182=EDGE_LOOP('',(#1181));
#1183=FACE_BOUND('',#1182,.T.);
#1184=ADVANCED_FACE('F713',(#1180,#1183),#1169,.F.);
#1185=CARTESIAN_POINT('',(20.,180.,-5.));
#1186=DIRECTION('',(0.,0.,-1.));
#1187=DIRECTION('',(-1.,0.,0.));
#1188=AXIS2_PLACEMENT_3D('',#1185,#1186,#1187);
#1189=PLANE('',#1188);
#1190=CARTESIAN_POINT('',(20.,180.,-5.));
#1191=DIRECTION('',(0.,0.,-1.));
#1192=DIRECTION('',(-1.,0.,0.));
#1193=AXIS2_PLACEMENT_3D('',#1190,#1191,#1192);
#1194=CIRCLE('',#1193,2.50000000000002);
#1195=CARTESIAN_POINT('',(17.4999999999999,180.,-5.));
#1196=VERTEX_POINT('',#1195);
#1197=EDGE_CURVE('E793',#1196,#1196,#1194,.T.);
#1198=ORIENTED_EDGE('',*,*,#1197,.F.);
#1199=EDGE_LOOP('',(#1198));
#1200=FACE_BOUND('',#1199,.T.);
#1201=ORIENTED_EDGE('',*,*,#1177,.T.);
#1202=EDGE_LOOP('',(#1201));
#1203=FACE_BOUND('',#1202,.T.);
#1204=ADVANCED_FACE('F721',(#1200,#1203),#1189,.T.);
#1205=CARTESIAN_POINT('',(20.,20.,-5.));
#1206=DIRECTION('',(0.,0.,-1.));
#1207=DIRECTION('',(-1.,0.,0.));
#1208=AXIS2_PLACEMENT_3D('',#1205,#1206,#1207);
#1209=CYLINDRICAL_SURFACE('',#1208,4.99999999999999);
#1210=CARTESIAN_POINT('',(20.,20.,-5.));
#1211=DIRECTION('',(0.,0.,-1.));
#1212=DIRECTION('',(-1.,0.,0.));
#1213=AXIS2_PLACEMENT_3D('',#1210,#1211,#1212);
#1214=CIRCLE('',#1213,4.99999999999999);
#1215=CARTESIAN_POINT('',(15.,20.,-5.));
#1216=VERTEX_POINT('',#1215);
#1217=EDGE_CURVE('E808',#1216,#1216,#1214,.T.);
#1218=ORIENTED_EDGE('',*,*,#1217,.F.);
#1219=EDGE_LOOP('',(#1218));
#1220=FACE_BOUND('',#1219,.T.);
#1221=ORIENTED_EDGE('',*,*,#166,.T.);
#1222=EDGE_LOOP('',(#1221));
#1223=FACE_BOUND('',#1222,.T.);
#1224=ADVANCED_FACE('F729',(#1220,#1223),#1209,.F.);
#1225=CARTESIAN_POINT('',(20.,20.,-5.));
#1226=DIRECTION('',(0.,0.,-1.));
#1227=DIRECTION('',(-1.,0.,0.));
#1228=AXIS2_PLACEMENT_3D('',#1225,#1226,#1227);
#1229=PLANE('',#1228);
#1230=CARTESIAN_POINT('',(20.,20.,-5.));
#1231=DIRECTION('',(0.,0.,-1.));
#1232=DIRECTION('',(-1.,0.,0.));
#1233=AXIS2_PLACEMENT_3D('',#1230,#1231,#1232);
#1234=CIRCLE('',#1233,2.50000000000002);
#1235=CARTESIAN_POINT('',(17.4999999999999,20.,-5.));
#1236=VERTEX_POINT('',#1235);
#1237=EDGE_CURVE('E785',#1236,#1236,#1234,.T.);
#1238=ORIENTED_EDGE('',*,*,#1237,.F.);
#1239=EDGE_LOOP('',(#1238));
#1240=FACE_BOUND('',#1239,.T.);
#1241=ORIENTED_EDGE('',*,*,#1217,.T.);
#1242=EDGE_LOOP('',(#1241));
#1243=FACE_BOUND('',#1242,.T.);
#1244=ADVANCED_FACE('F737',(#1240,#1243),#1229,.T.);
#1245=CARTESIAN_POINT('',(280.,20.,0.));
#1246=DIRECTION('',(0.,0.,-1.));
#1247=DIRECTION('',(-1.,0.,0.));
#1248=AXIS2_PLACEMENT_3D('',#1245,#1246,#1247);
#1249=CYLINDRICAL_SURFACE('',#1248,2.50000000000002);
#1250=ORIENTED_EDGE('',*,*,#449,.F.);
#1251=EDGE_LOOP('',(#1250));
#1252=FACE_BOUND('',#1251,.T.);
#1253=ORIENTED_EDGE('',*,*,#1157,.T.);
#1254=EDGE_LOOP('',(#1253));
#1255=FACE_BOUND('',#1254,.T.);
#1256=ADVANCED_FACE('F745',(#1252,#1255),#1249,.F.);
#1257=CARTESIAN_POINT('',(20.,180.,0.));
#1258=DIRECTION('',(0.,0.,-1.));
#1259=DIRECTION('',(-1.,0.,0.));
#1260=AXIS2_PLACEMENT_3D('',#1257,#1258,#1259);
#1261=CYLINDRICAL_SURFACE('',#1260,2.50000000000002);
#1262=ORIENTED_EDGE('',*,*,#438,.F.);
#1263=EDGE_LOOP('',(#1262));
#1264=FACE_BOUND('',#1263,.T.);
#1265=ORIENTED_EDGE('',*,*,#1197,.T.);
#1266=EDGE_LOOP('',(#1265));
#1267=FACE_BOUND('',#1266,.T.);
#1268=ADVANCED_FACE('F753',(#1264,#1267),#1261,.F.);
#1269=CARTESIAN_POINT('',(20.,20.,0.));
#1270=DIRECTION('',(0.,0.,-1.));
#1271=DIRECTION('',(-1.,0.,0.));
#1272=AXIS2_PLACEMENT_3D('',#1269,#1270,#1271);
#1273=CYLINDRICAL_SURFACE('',#1272,2.50000000000002);
#1274=ORIENTED_EDGE('',*,*,#427,.F.);
#1275=EDGE_LOOP('',(#1274));
#1276=FACE_BOUND('',#1275,.T.);
#1277=ORIENTED_EDGE('',*,*,#1237,.T.);
#1278=EDGE_LOOP('',(#1277));
#1279=FACE_BOUND('',#1278,.T.);
#1280=ADVANCED_FACE('F761',(#1276,#1279),#1273,.F.);
#1281=CARTESIAN_POINT('',(250.,11.,0.));
#1282=DIRECTION('',(0.,0.,-1.));
#1283=DIRECTION('',(-1.,0.,0.));
#1284=AXIS2_PLACEMENT_3D('',#1281,#1282,#1283);
#1285=CYLINDRICAL_SURFACE('',#1284,6.00000000000002);
#1286=ORIENTED_EDGE('',*,*,#416,.F.);
#1287=EDGE_LOOP('',(#1286));
#1288=FACE_BOUND('',#1287,.T.);
#1289=ORIENTED_EDGE('',*,*,#155,.T.);
#1290=EDGE_LOOP('',(#1289));
#1291=FACE_BOUND('',#1290,.T.);
#1292=ADVANCED_FACE('F768',(#1288,#1291),#1285,.F.);
#1293=CLOSED_SHELL('',(#58,#89,#120,#142,#403,#664,#686,#703,#720,#737,#754,#771,#788,#805,#822,
#839,#856,#873,#890,#907,#924,#941,#958,#975,#992,#1009,#1026,#1043,#1060,#1072,#1092,#1112,
#1124,#1144,#1164,#1184,#1204,#1224,#1244,#1256,#1268,#1280,#1292));
#1294=MANIFOLD_SOLID_BREP('B2',#1293);
#1295=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#1294),#14);
#1296=SHAPE_DEFINITION_REPRESENTATION(#9,#1295);
ENDSEC;
END-ISO-10303-21;
